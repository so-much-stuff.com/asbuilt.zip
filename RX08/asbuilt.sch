# EAGLE board asbuilt (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$93 (continued)
  Top 0.254: E18.6 139.7,72.39 137.16,74.93 137.16,77.47 E19.10
N$94
  Top 0.254: 64.77,78.74 66.04,80.01 66.04,80.64 R18.1 | 64.77,78.74 63.5,77.47 IC9.3 | 64.77,78.74 64.77,57.15 69.22,57.15 74.3,62.23 74.3,66.04 90.17,66.04 91.44,64.77 E30.11
N$95
  Bottom 0.254: IC9.2 66.67,76.83 67.94,78.11 83.19,78.11 E31.8
N$96  (via drill 0.61)
  Top 0.254: v146.05,83.19 146.05,69.85 143.51,67.31 143.51,61.59 141.6,61.59 140.34,62.87 E18.9 | v179.07,83.19 179.07,91.44 177.8,92.71 E17.14
  Bottom 0.254: v179.07,83.19 v146.05,83.19
N$97  (via drill 0.61)
  Top 0.254: v181.61,105.41 182.88,104.14 182.88,102.87 E17.1 | v214,104.78 v214,89.53 | v220.98,89.53 220.98,87.63 IC11.6
  Bottom 0.254: v181.61,105.41 182.25,104.78 v214,104.78 | v214,89.53 v220.98,89.53
N$98  (via drill 0.61)
  Top 0.254: v71.75,85.09 71.75,80.64 68.58,77.47 IC9.1
  Bottom 0.254: v71.75,85.09 72.39,84.45 84.45,84.45 85.72,85.72 E31.6
N$99
  Bottom 0.254: E30.13 97.16,64.14 98.42,65.41 107.31,65.41 108.58,64.14 E24.8
N$100
  Top 0.254: E25.10 114.3,80.01 115.57,81.28 115.57,87.63 113.03,90.17 113.03,104.78 118.75,110.49 120.65,110.49 120.65,96.52 119.38,95.25 E26.12 120.02,93.34 121.28,93.34 E26.13
N$101  (via drill 0.61)
  Top 0.508: v71.12,76.2 69.85,74.93 69.85,62.23 v66.04,58.42
  Bottom 0.508: E36.11 41.27,47.62 42.55,47.62 E36.12 43.81,48.9 46.99,52.07 59.69,52.07 59.69,53.98 60.33,54.61 62.23,54.61 v66.04,58.42 | v71.12,76.2 116.84,76.2 118.75,78.11 E25.12
N$102
  Bottom 0.254: E31.13 97.16,78.11 98.42,76.83 107.31,76.83 108.58,78.11 E25.8
N$103  (via drill 0.61)
  Top 0.254: v227.33,105.41 227.33,88.9 228.6,87.63 IC11.3 | v180.97,108.58 179.71,109.86 172.09,109.86 172.09,108.58 166.37,102.87 v166.37,99.69
  Bottom 0.254: v227.33,105.41 224.16,108.58 v180.97,108.58 | v166.37,99.69 165.1,98.42 114.94,98.42 112.39,100.97 E26.6
N$104
  Bottom 0.254: E10.6 196.22,100.97 197.49,99.69 206.38,99.69 207.65,100.97 E10.1
N$105
  Top 0.254: E10.10 198.75,93.34 200.03,93.34 E10.11
  Bottom 0.254: E10.12 202.56,93.34 201.29,93.34 E10.11
N$106  (via drill 0.61)
  Top 0.254: IC7.2 66.67,100.97 67.94,100.97 IC7.1 | v179.71,108.58 193.04,95.25 E10.8
  Bottom 0.254: v179.71,108.58 179.07,107.95 112.39,107.95 109.86,105.41 96.52,105.41 95.25,106.68 73.66,106.68 69.22,102.23 IC7.1
N$107  (via drill 0.61)
  Top 0.254: v194.31,90.17 v194.31,83.19 | v187.96,98.42 v187.96,90.17 | v181.61,98.42 181.61,104.14 v180.34,105.41 | v160.02,102.23 v160.02,105.41 | v154.31,102.23 153.67,102.87 153.67,103.5 v152.4,104.78 | v119.38,104.78 119.38,102.87 E26.3
  Bottom 0.254: v194.31,83.19 212.09,83.19 212.72,83.82 231.14,83.82 232.41,85.09 233.68,85.09 IC11.1 | v187.96,90.17 v194.31,90.17 | v181.61,98.42 v187.96,98.42 | v180.34,105.41 179.71,106.05 160.66,106.05 v160.02,105.41 | v154.31,102.23 v160.02,102.23 | v152.4,104.78 151.76,104.14 120.02,104.14 v119.38,104.78
PARITY
  Top 0.254: E15.13 177.8,66.04 177.8,71.12 E15.2
  Bottom 0.254: E4.15 230.5,46.35 225.43,51.44 217.81,51.44 217.17,52.07 217.17,61.59 200.03,61.59 199.39,62.23 199.39,65.41 184.15,65.41 181.61,62.87 179.71,62.87 178.44,64.14 E15.13 | E15.1 179.71,71.75 178.44,71.75 E15.2
PARITY\  (via drill 0.61)
  Top 0.254: v168.91,75.56 168.91,91.44 167.64,92.71 E17.10 | v175.26,75.56 176.53,74.3 176.53,67.31 175.26,66.04 E15.12
  Bottom 0.254: v168.91,75.56 v175.26,75.56
RD  (via drill 0.61)
  Top 0.254: v87.63,83.82 87.63,91.44 88.9,92.71 E32.10
  Bottom 0.254: 87.63,83.19 117.47,83.19 118.75,84.45 122.56,84.45 123.83,85.72 E25.1 | 87.63,83.19 72.39,83.19 70.48,85.09 8.26,85.09 8.26,33.02 9.53,31.75 13.34,31.75 13.97,31.11 36.2,31.11 37.47,32.38 E35.10 | 87.63,83.19 v87.63,83.82
RUN  (via drill 0.61)
  Top 0.254: v67.94,65.41 66.04,67.31 IC9.7
  Bottom 0.254: v67.94,65.41 84.45,65.41 85.72,64.14 E30.9 87,62.87 88.9,60.96 132.72,60.96 133.35,61.59 142.88,61.59 144.15,62.87 E18.11 | IC9.6 64.14,67.94 65.41,67.94 IC9.7
RX_12_BIT\
  Top 0.254: R7.1 23.5,22.86 24.77,22.86 R16.2 | IC8.3 17.78,66.04 16.51,64.77 16.51,27.3 12.7,23.5 DRIVE.FF
  Bottom 0.254: R7.1 22.23,22.86 20.95,21.59 14.61,21.59 13.34,22.86 DRIVE.FF
RX_DATA  (via drill 0.61)
  Top 0.254: v119.38,10.16 125.73,16.51 125.73,26.67 123.19,29.21 123.19,38.1 121.92,39.37 E22.3 122.56,40.01 123.83,40.01 E22.2
  Bottom 0.254: v119.38,10.16 82.55,10.16 78.74,6.35 57.15,6.35 57.15,30.48 48.26,39.37 E35.1
RX_DATA\
  Top 0.254: R8.1 18.41,22.86 19.68,22.86 R17.2 | IC7.5 60.33,93.98 49.53,93.98 49.53,45.72 45.72,41.91 E35.2
  Bottom 0.254: E35.2 45.09,40.01 39.37,34.29 39.37,28.57 19.05,28.57 19.05,27.94 | 19.05,27.94 19.05,24.77 17.78,23.5 R8.1 | 19.05,27.94 13.34,27.94 DRIVE.BB
RX_DONE\  (via drill 0.61)
  Top 0.254: R4.1 23.5,48.26 24.77,48.26 R13.2 26.04,48.26 32.38,48.26 E36.8 | v15.24,41.91 15.24,36.2 12.7,33.66 DRIVE.X
  Bottom 0.254: R4.1 22.23,48.26 20.95,46.99 20.32,46.99 v15.24,41.91
RX_ERROR\
  Top 0.254: R14.2 18.41,48.26 19.68,48.26 R5.1
  Bottom 0.254: E36.3 42.55,56.52 41.27,57.78 30.48,57.78 20.95,48.26 R5.1 | 17.14,48.26 R14.2 17.14,48.26 | 17.14,48.26 13.34,48.26 DRIVE.J
RX_INIT\
  Top 0.254: R20.1 24.77,35.56 23.5,35.56 R9.1 | IC8.5 15.24,58.42 13.97,57.15 13.97,45.09 12.7,43.81 DRIVE.N
  Bottom 0.254: R9.1 22.23,35.56 20.95,34.29 15.88,34.29 13.34,36.83 12.06,36.83 11.43,37.47 11.43,43.18 12.06,43.18 DRIVE.N
RX_OUT\
  Top 0.254: 29.21,22.86 28.57,22.86 R12.2 | 29.21,22.86 29.84,22.86 R3.1 | 29.21,22.86 29.21,27.94 33.02,31.75 E35.8
  Bottom 0.254: 20.32,20.95 19.05,20.95 | 20.32,20.95 25.4,20.95 27.3,22.86 R12.2 | 20.32,20.95 12.7,13.34 DRIVE.RR
RX_RUN\
  Top 0.254: IC9.5 60.96,67.31 60.96,61.59 R6.1
  Bottom 0.254: R15.2 65.41,63.5 64.14,63.5 61.59,60.96 R6.1 60.33,60.96 32.38,60.96 29.21,57.78 17.78,57.78 13.34,53.34 DRIVE.D
RX_SHIFT\
  Top 0.254: R2.1 29.84,35.56 28.57,35.56 R10.2 27.94,34.92 21.59,28.57 21.59,24.77 20.95,24.13 17.14,24.13 16.51,23.5 16.51,22.23 12.7,18.41 DRIVE.LL
  Bottom 0.254: E35.5 38.1,39.37 38.1,36.2 30.48,36.2 R2.1
RX_TR_REQ\  (via drill 0.61)
  Top 0.254: v36.83,38.73 36.83,53.34 38.1,54.61 E36.5
  Bottom 0.254: R11.2 18.41,35.56 19.68,35.56 R1.1 20.95,35.56 22.23,36.83 34.92,36.83 v36.83,38.73 | 17.14,35.56 R11.2 | 17.14,35.56 15.88,35.56 13.34,38.1 DRIVE.T | 17.14,35.56 R11.2
SDN4\  (via drill 0.61)
  Top 0.254: v158.12,29.21 153.67,24.77 153.67,20.95 151.76,19.05 149.86,19.05 149.86,56.52 147.32,59.05 137.16,59.05 137.16,62.23 E18.8
  Bottom 0.254: v158.12,29.21 161.29,29.21 161.93,28.57 165.74,28.57 167,29.84 E13.10
SER4\  (via drill 0.61)
  Top 0.254: v154.31,31.75 153.03,33.02 153.03,60.33 151.13,62.23 v151.13,69.22
  Bottom 0.254: v154.31,31.75 161.29,31.75 161.93,32.38 168.28,32.38 169.54,31.11 E13.11 | v151.13,69.22 144.15,69.22 142.88,70.48 E18.5
SHIFT
  Top 0.254: E35.4 40.64,41.91 41.91,43.18 41.91,83.19 46.99,88.27 46.99,92.71 50.8,96.52 61.59,96.52 61.59,99.69 62.23,100.33 62.23,102.87 62.87,103.5 93.98,103.5 93.98,102.87 E32.3
STR2\  (via drill 0.61)
  Top 0.254: v152.4,21.59 152.4,58.42 148.59,62.23 148.59,68.58 149.86,69.85 E18.2
  Bottom 0.254: v152.4,21.59 161.29,21.59 162.56,20.32 170.18,20.32 172.09,18.41 E12.12
TR_SKIP  (via drill 0.61)
  Top 0.254: E18.1 151.76,71.75 151.13,72.39 v151.13,76.83 151.13,96.52 152.4,97.79 152.4,100.33 E20.1 | v126.36,93.34 125.73,93.98 125.73,103.5 123.83,103.5 122.56,102.23 E26.2 | v129.54,93.34 128.91,92.71 128.91,79.38 v130.81,77.47
  Bottom 0.254: v129.54,93.34 v126.36,93.34 | v130.81,77.47 132.72,77.47 133.35,76.83 v151.13,76.83
VCC  (via drill 0.61)
  Top 0.508: E2.12 225.43,19.68 224.16,19.68 E2.11 222.88,19.68 221.62,19.68 E2.10 220.98,19.05 220.98,16.51 E1.5 221.62,14.61 222.88,14.61 E1.4 | C1.1 233.68,9.53 234.95,10.79 234.95,19.68 233.68,20.95 C2.1 | 234.95,60.33 233.68,61.59 233.68,62.23 E5.14 | 234.95,60.33 236.22,59.05 R19.1 | 234.95,78.11 236.22,79.38 C6.1 | 234.95,60.33 234.95,78.11 | 234.95,78.11 234.95,85.72 235.59,86.36 235.59,93.98 236.22,94.61 C7.1 | 234.95,60.33 234.95,48.9 236.22,47.62 C4.1 | 232.41,36.2 231.78,36.83 231.78,41.91 233.68,43.81 233.68,44.45 E4.16 | 232.41,36.2 233.68,34.92 C3.1 | E11.16 182.88,6.35 181.61,7.62 181.61,15.24 182.88,16.51 E12.16 | 184.15,27.94 182.88,29.21 E13.16 | 184.15,27.94 184.15,22.23 185.42,20.95 185.42,19.68 C12.1 | 184.15,27.94 184.15,48.26 182.88,49.53 E14.16 182.88,52.07 182.25,52.7 182.25,56.52 181.61,57.15 181.61,59.69 182.88,60.96 182.88,65.41 C15.1 182.88,66.67 184.15,67.94 184.15,82.55 | C20.1 154.94,94.61 154.94,85.72 C19.1 154.94,84.45 153.67,83.19 153.67,78.11 | 153.67,78.11 153.67,66.67 154.94,65.41 C18.1 | E16.10 170.18,80.01 172.72,82.55 172.72,85.09 E16.4 172.72,87.63 173.99,88.9 173.99,99.06 172.72,100.33 E17.5 | C8.1 210.82,65.41 212.09,66.67 212.09,78.11 210.82,79.38 C9.1 | 184.15,82.55 182.88,81.28 182.88,80.64 C16.1 | 184.15,82.55 186.69,85.09 v186.69,93.98 186.69,98.42 185.42,99.69 C17.1 | 128.27,30.48 128.27,20.95 129.54,19.68 C21.1 | 128.27,30.48 127,31.75 E22.16 | 128.27,30.48 128.27,45.72 127,46.99 E23.16 | E20.10 142.24,92.71 v142.24,90.81 142.24,87.63 E19.5 142.24,85.09 142.24,80.01 E19.12 | E32.14 99.06,92.71 106.05,85.72 106.05,68.58 115.57,68.58 115.57,75.56 116.2,76.2 121.28,76.2 121.28,78.11 E25.13
  Top 0.508: C24.1 127,65.41 125.73,66.67 125.73,76.2 124.46,77.47 E25.14 | E26.14 124.46,92.71 125.73,91.44 125.73,82.55 127,81.28 127,80.64 C25.1 | C23.1 129.54,50.16 128.27,51.44 128.27,58.42 124.46,62.23 E24.14 | C35.1 50.8,34.92 52.07,36.2 52.07,46.35 50.8,47.62 C36.1 50.8,48.9 53.34,51.44 53.34,84.45 | R1.2 20.32,26.04 19.05,27.3 19.05,36.2 20.32,37.47 R5.2 20.95,38.1 22.23,38.1 R4.2 22.86,38.73 21.59,40.01 21.59,57.15 22.86,58.42 IC8.8 | R7.2 22.86,13.34 21.59,14.61 21.59,23.5 22.86,24.77 R9.2 23.5,25.4 24.77,25.4 R20.2 | 53.34,84.45 50.8,87 50.8,92.08 C38.1 | 53.34,84.45 55.88,81.92 C37.1 | 72.39,62.87 73.66,64.14 73.66,67.31 | 72.39,62.87 71.12,61.59 R6.2 | 73.66,67.31 73.66,69.22 C33.1 73.66,70.48 74.93,71.75 74.93,79.38 76.2,80.64 R18.2 | 72.39,62.87 72.39,82.55 73.03,83.19 73.03,88.27 68.58,92.71 IC7.8 | IC3.8 86.36,19.05 85.09,20.32 85.09,30.48 86.36,31.75 IC2.8 86.36,34.29 87.63,35.56 87.63,50.8 | 87.63,50.8 88.9,52.07 88.9,62.23 E30.10 | 87.63,50.8 86.36,49.53 IC6.8 | 100.33,63.5 100.97,63.5 C30.1 | 100.33,63.5 99.69,63.5 E30.14 | 91.44,67.31 93.98,64.77 E30.12 | 91.44,67.31 91.44,69.85 E30.4 92.08,71.75 98.42,78.11 E31.14 | 100.33,63.5 100.33,51.44 101.6,50.16 C29.1 | 91.44,67.31 73.66,67.31 | 232.41,36.2 232.41,26.67 231.78,26.04 231.78,22.23 231.14,21.59 E2.14 | 153.67,78.11 153.03,78.11 E19.16 | 234.95,78.11 234.31,78.11 IC11.14
  Bottom 0.508: E1.14 231.78,8.26 232.41,8.89 233.04,8.89 C1.1 | E2.12 226.69,19.68 227.97,19.68 E2.13 229.24,19.68 230.5,19.68 E2.14 231.78,20.95 232.41,20.95 233.04,21.59 C2.1 | E10.14 208.91,94.61 209.55,95.25 210.19,95.25 C10.1 211.46,95.25 212.09,95.89 236.22,95.89 C7.1 | E4.16 234.31,46.35 234.95,46.99 235.59,46.99 C4.1 | E5.14 234.31,64.14 234.95,64.77 235.59,64.77 C5.1 | 182.88,52.7 185.42,52.7 C14.1 | 182.88,52.7 175.9,52.7 170.81,57.78 E14.6 | 182.88,52.7 182.88,52.07 E14.16 | E13.16 183.51,31.11 184.15,31.75 184.78,31.75 C13.1 | E11.16 183.51,5.71 184.15,6.35 184.78,6.35 C11.1 | E12.16 183.51,18.41 184.15,19.05 184.78,19.05 C12.1 | E18.14 153.03,64.14 153.67,64.77 154.31,64.77 C18.1 | E20.14 153.03,94.61 153.67,95.25 154.31,95.25 C20.1 155.57,95.25 156.21,95.89 165.74,95.89 166.37,95.25 166.37,90.81 v142.24,90.81 | E17.7 168.28,100.97 169.54,99.69 170.81,99.69 172.09,100.97 E17.5 173.35,101.6 174.62,101.6 E17.4 | E8.14 208.91,64.14 209.55,64.77 210.19,64.77 C8.1 | E15.14 180.97,65.41 181.61,66.04 182.25,66.04 C15.1 | E16.14 180.97,79.38 181.61,80.01 182.25,80.01 C16.1 | 182.88,80.64 203.84,80.64 205.1,79.38 IC10.8 206.38,79.38 207.01,80.01 210.19,80.01 C9.1 210.82,80.64 231.78,80.64 233.04,79.38 IC11.14 | 182.88,80.64 C16.1 | 182.88,80.64 172.09,80.64 170.81,79.38 E16.10 | 182.88,80.64 C16.1 | C19.1 155.57,85.09 156.21,84.45 170.81,84.45 172.09,85.72 E16.4 | E23.16 127.64,48.9 128.27,49.53 128.91,49.53 C23.1 | E21.16 127.64,18.41 128.27,19.05 128.91,19.05 C21.1 | E22.16 127.64,33.66 128.27,34.29 128.91,34.29 C22.1 | E26.14 125.09,94.61 125.73,95.25 126.36,95.25 C26.1 127.64,95.25 128.27,95.89 137.79,95.89 139.06,94.61 E20.9 140.34,93.34 141.6,93.34 E20.10
  Bottom 0.508: E24.14 125.09,64.14 125.73,64.77 126.36,64.77 C24.1 | E32.14 99.69,94.61 100.33,95.25 100.97,95.25 C32.1 | 124.46,80.64 127,80.64 C25.1 | 124.46,80.64 121.92,80.64 | 121.92,80.64 118.75,80.64 117.47,79.38 E25.11 116.2,79.38 114.94,80.64 101.6,80.64 C31.1 100.97,80.01 100.33,80.01 99.69,79.38 E31.14 | 121.92,80.64 121.92,80.01 E25.13 | 124.46,80.64 124.46,80.01 E25.14 125.09,78.74 133.99,78.74 E19.9 | E36.14 48.9,48.26 50.16,48.26 C36.1 | C35.1 50.16,34.29 49.53,34.29 48.9,33.66 E35.14 47.62,32.38 40.64,25.4 31.11,25.4 R2.2 29.84,25.4 28.57,26.67 27.3,26.67 26.04,25.4 R20.2 | 20.95,13.97 19.68,13.97 18.41,12.7 R8.2 | 20.95,13.97 22.23,12.7 R7.2 | 20.95,13.97 28.57,13.97 29.84,12.7 R3.2 | R1.2 20.95,25.4 22.23,25.4 R9.2 23.5,25.4 | IC7.8 69.22,94.61 69.85,95.25 73.03,95.25 C34.1 | IC9.8 69.22,69.22 69.85,69.85 73.03,69.85 C33.1 | C37.1 56.52,81.28 57.78,80.01 74.3,80.01 75.56,81.28 R18.2 | IC3.8 87,18.41 88.27,19.68 97.16,19.68 98.42,18.41 IC4.8 99.69,18.41 100.33,18.41 100.97,19.05 C27.1 | 99.06,34.92 101.6,34.92 C28.1 | 99.06,34.92 88.27,34.92 87,33.66 IC2.8 | 99.06,34.92 99.06,34.29 IC1.8 | IC5.8 99.69,48.9 100.33,49.53 100.97,49.53 C29.1 | 95.89,61.59 97.16,61.59 98.42,62.87 E30.14 | 95.89,61.59 94.61,62.87 E30.12 | 95.89,61.59 90.81,61.59 89.53,62.87 E30.10 | 21.59,73.03 31.75,73.03 C40.+ | C39.1 27.3,60.96 24.13,60.96 23.5,60.33 IC8.8 22.86,60.96 21.59,60.96 21.59,73.03 | 21.59,73.03 19.68,73.03 19.05,73.66 SL1.1 | E19.4 144.15,86.36 142.88,86.36 E19.5 | v186.69,93.98 183.51,93.98 E17.16
WRT  (via drill 0.61)
  Top 0.254: v70.48,83.82 70.48,85.72 63.5,92.71 IC7.6 | v118.11,82.55 121.28,85.72 E25.2 | E15.10 170.18,63.5 166.37,59.69 166.37,57.15 165.74,56.52 161.93,56.52 161.93,63.5 160.02,65.41 v160.02,81.92 160.02,99.06 173.35,112.39 191.13,112.39 191.13,109.86 198.12,102.87 E10.5
  Bottom 0.254: v70.48,83.82 71.75,82.55 93.98,82.55 94.61,81.92 116.2,81.92 116.84,82.55 v118.11,82.55 118.75,83.19 133.99,83.19 135.25,81.92 v160.02,81.92
XDR2
  Top 0.254: E10.2 205.74,100.33 209.55,96.52 209.55,88.27 214,83.82 214,69.22 218.44,64.77 E5.8
  Bottom 0.254: E5.8 219.07,62.87 220.34,61.59 226.69,61.59 227.97,62.87 E5.12
XDR2\  (via drill 0.61)
  Top 0.254: v44.45,62.23 44.45,35.56 43.18,34.29 E35.12 | v111.76,74.93 111.76,77.47 E25.9 | v116.84,74.93 116.84,72.39 E24.4 | v203.2,17.78 204.47,19.05 204.47,59.69 207.01,62.23 v207.01,65.41 | v156.21,75.56 159.38,72.39 159.38,44.45 161.93,44.45 168.91,44.45 168.91,34.29 171.45,31.75 171.45,16.51 173.99,13.97 173.99,11.43 174.62,10.79 176.53,10.79 176.53,13.97 175.26,15.24 175.26,16.51 E12.13
  Bottom 0.254: E5.10 222.88,62.87 221.62,62.87 E5.9 220.34,64.14 218.44,66.04 207.65,66.04 v207.01,65.41 | v44.45,62.23 48.9,66.67 99.06,66.67 100.33,67.94 100.97,67.31 113.03,67.31 116.2,70.48 E24.4 | v111.76,74.93 v116.84,74.93 117.47,75.56 v156.21,75.56 | v203.2,17.78 197.49,17.78 196.22,19.05 191.77,19.05 188.59,15.88 177.16,15.88 175.9,17.14 E12.13
XFER_REQ  (via drill 0.61)
  Top 0.254: v41.27,83.82 41.27,56.52 E36.4 | v63.5,83.82 v63.5,91.44 | v123.19,90.81 123.19,95.89 124.46,97.16 124.46,100.33 E26.1 | v147.32,89.53 147.32,92.71 E20.12
  Bottom 0.254: v41.27,83.82 41.91,84.45 62.87,84.45 v63.5,83.82 | v63.5,91.44 122.56,91.44 | 122.56,91.44 v123.19,90.81 | v147.32,89.53 142.24,89.53 140.34,91.44 122.56,91.44

## Text on the board
Bottom: RX08 Floppy Interface | VRS
tPlace: RX08 Floppy Interface | VRS
tNames: GND | VCC